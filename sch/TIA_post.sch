v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -50 -70 0 0 {name=p1 lab=vin1}
C {devices/ipin.sym} -50 -30 0 0 {name=p2 lab=vin2}
C {devices/opin.sym} 70 -70 0 0 {name=p3 lab=vout1}
C {devices/opin.sym} 70 -30 0 0 {name=p4 lab=vout2}
C {devices/iopin.sym} 0 -100 0 0 {name=p5 lab=vdd}
C {devices/iopin.sym} 0 10 0 0 {name=p6 lab=vss}
